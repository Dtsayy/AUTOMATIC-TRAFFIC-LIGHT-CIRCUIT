# Keil uVision project Hello.uvproj, settings and files
target Simulator (MCS-51)
  device: 8xC52 Philips
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: HELLO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HELLO.asm
  group Documentation
    ./: ABSTRACT.TXT
